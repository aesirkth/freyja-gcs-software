## spoofer/boards/aesir/freyja_gcs/board.yml
```yaml
board:
  name: freyja_gcs
  full_name: freyja ground control station
  vendor: aesir
  socs:
    - name: stm32u575xx
```
